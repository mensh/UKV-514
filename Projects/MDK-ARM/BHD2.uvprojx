# Keil uVision project BHD2.uvprojx, settings and files
target BHD2 Configuration (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F215ZG STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.5.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: BHD2 Configuration +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F215xx
  c misc: --C99
  c include: ..\..\Drivers\CMSIS\Device\ST\STM32F2xx\Include;..\..\Drivers\CMSIS\Include;..\..\Middlewares\ST\STM32_USB_Device_Library\Class\CDC\Inc;..\..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc;..\..\Drivers\STM32F2xx_HAL_Driver\Inc;..\..\Inc;..\..\Src\flash
  asm include: ..\..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --diag_suppress=L6329
  group Application/MDK-ARM
    ../../Drivers/CMSIS/Device/ST/STM32F2xx/Source/Templates/arm/: startup_stm32f215xx.s
  group Application/User
    ../../Src/: can.c dma.c fsmc.c gpio.c main.c stm32f2xx_it.c rng.c usb_device.c usbd_cdc_if.c usbd_conf.c usbd_desc.c stm32DebugPrint.c spi.c dac.c usart.c
  group Application/Core
    ../../Src/core/: core.c counter.c crc.c dataStream.c eepromDriver.c fileSystem.c holtCore.c holtDriver.c nand_MT29F_lld.c spiDriver.c usbCore.c map.c adcCore.c timCore.c
    ../../Src/: calc_vibration.c iir_filter.c FIFO.c vsk.c adc.c usart_work.c ringbuffer.c
  group Drivers/CMSIS
    ../../Drivers/CMSIS/Device/ST/STM32F2xx/Source/Templates/: system_stm32f2xx.c
  group Drivers/STM32F2xx_HAL_Driver
    ../../Drivers/STM32F2xx_HAL_Driver/Src/: stm32f2xx_hal.c stm32f2xx_hal_adc.c stm32f2xx_hal_adc_ex.c stm32f2xx_hal_can.c stm32f2xx_hal_cortex.c stm32f2xx_hal_dma.c stm32f2xx_hal_dma_ex.c stm32f2xx_hal_flash.c stm32f2xx_hal_flash_ex.c stm32f2xx_hal_gpio.c stm32f2xx_hal_nand.c stm32f2xx_hal_pcd.c stm32f2xx_hal_pwr.c stm32f2xx_hal_pwr_ex.c stm32f2xx_hal_rcc.c stm32f2xx_hal_rcc_ex.c stm32f2xx_hal_spi.c stm32f2xx_ll_fsmc.c stm32f2xx_ll_usb.c stm32f2xx_hal_rng.c stm32f2xx_hal_tim.c stm32f2xx_hal_tim_ex.c stm32f2xx_hal_dac.c stm32f2xx_hal_dac_ex.c stm32f2xx_hal_uart.c
  group Middlewares/USB_Device_Library
    ../../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
    ../../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
  group Doc
    ../../: ToDo.txt
  group Flash
    ../../Src/flash/: cfg_pool.c cfg_storage.c crc16.c flash.c flash_sec.c
software components: CMSIS:CORE 4.3.0
